# Keil uVision project STM32H743.uvprojx, settings and files
target STM32H743 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.2
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H743 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Drivers/User/Inc;..\Middware\LVGL;..\Middware\LVGL\examples\porting;..\Middware\LVGL\src;..\Middware\LVGL\src\core;..\Middware\LVGL\src\draw;..\Middware\LVGL\src\draw\nxp_pxp;..\Middware\LVGL\src\draw\nxp_vglite;..\Middware\LVGL\src\draw\sdl;..\Middware\LVGL\src\draw\stm32_dma2d;..\Middware\LVGL\src\draw\sw;..\Middware\LVGL\src\extra;..\Middware\LVGL\src\extra\layouts;..\Middware\LVGL\src\extra\layouts\flex;..\Middware\LVGL\src\extra\layouts\grid;..\Middware\LVGL\src\extra\libs;..\Middware\LVGL\src\extra\libs\bmp;..\Middware\LVGL\src\extra\libs\ffmpeg;..\Middware\LVGL\src\extra\libs\freetype;..\Middware\LVGL\src\extra\libs\fsdrv;..\Middware\LVGL\src\extra\libs\gif;..\Middware\LVGL\src\extra\libs\png;..\Middware\LVGL\src\extra\libs\qrcode;..\Middware\LVGL\src\extra\libs\rlottie;..\Middware\LVGL\src\extra\libs\sjpg;..\Middware\LVGL\src\extra\others;..\Middware\LVGL\src\extra\others\gridnav;..\Middware\LVGL\src\extra\others\monkey;..\Middware\LVGL\src\extra\others\snapshot;..\Middware\LVGL\src\extra\themes;..\Middware\LVGL\src\extra\themes\basic;..\Middware\LVGL\src\extra\themes\default;..\Middware\LVGL\src\extra\themes\mono;..\Middware\LVGL\src\extra\widgets;..\Middware\LVGL\src\extra\widgets\animimg;..\Middware\LVGL\src\extra\widgets\calendar;..\Middware\LVGL\src\extra\widgets\chart;..\Middware\LVGL\src\extra\widgets\colorwheel;..\Middware\LVGL\src\extra\widgets\imgbtn;..\Middware\LVGL\src\extra\widgets\keyboard;..\Middware\LVGL\src\extra\widgets\led;..\Middware\LVGL\src\extra\widgets\list;..\Middware\LVGL\src\extra\widgets\menu;..\Middware\LVGL\src\extra\widgets\meter;..\Middware\LVGL\src\extra\widgets\msgbox;..\Middware\LVGL\src\extra\widgets\span;..\Middware\LVGL\src\extra\widgets\spinbox;..\Middware\LVGL\src\extra\widgets\spinner;..\Middware\LVGL\src\extra\widgets\tabview;..\Middware\LVGL\src\extra\widgets\tileview;..\Middware\LVGL\src\extra\widgets\win;..\Middware\LVGL\src\font;..\Middware\LVGL\src\gpu;..\Middware\LVGL\src\hal;..\Middware\LVGL\src\misc;..\Middware\LVGL\src\widgets;..\Middware\App;..\Middware\Third_Party\FreeRTOS\Source;..\Middware\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2;..\Middware\Third_Party\FreeRTOS\Source\include;..\Middware\Third_Party\FreeRTOS\Source\portable\MemMang;..\Middware\Third_Party\FreeRTOS\Source\portable\RVDS;..\Middware\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\Drivers\Algorithm;..\Drivers\Hardware;..\Middware\LVGL\demos\01_interactive_page;..\Middware\LVGL\demos\01_interactive_page\fonts;..\Middware\LVGL\demos\01_interactive_page\components;..\Middware\LVGL\demos\01_interactive_page\screens;..\Middware\LVGL\demos\01_interactive_page\images;..\USB_DEVICE\App;..\USB_DEVICE\Target;..\Middware\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\Middware\ST\STM32_USB_Device_Library\Class\CDC\Src;..\Middware\ST\STM32_USB_Device_Library\Core\Src;..\Middware\ST\STM32_USB_Device_Library\Core\Inc;..\Drivers\System;..\Middware\Third_Party\FATFS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1c0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  link misc: --no_strict_wchar_size
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
    ../Drivers/User/Src/: stm32h7xx_hal_timbase_tim.c freertos.c gpio.c tim.c usart.c dma.c i2c.c sdmmc_sd.c
    ../Drivers/User/Inc/: FreeRTOSConfig.h gpio.h tim.h usart.h dma.h i2c.h
  group Drivers/User
    ../Drivers/User/Src/: led.c sdram.c lcd_rgb.c lcd_fonts.c touch_iic.c touch_800x480.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_sd.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_qspi.c
  group LVGL_Porting
    ../Middware/LVGL/examples/porting/: lv_port_disp_template.c lv_port_indev_template.c
    ../Middware/LVGL/: lv_conf.h lvgl.h
  group LVGL_Driver
    ../Middware/LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Middware/LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Middware/LVGL/src/draw/nxp_pxp/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../Middware/LVGL/src/draw/nxp_vglite/: lv_gpu_nxp_vglite.c
    ../Middware/LVGL/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../Middware/LVGL/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../Middware/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ../Middware/LVGL/src/extra/: lv_extra.c
    ../Middware/LVGL/src/extra/layouts/flex/: lv_flex.c
    ../Middware/LVGL/src/extra/layouts/grid/: lv_grid.c
    ../Middware/LVGL/src/extra/libs/bmp/: lv_bmp.c
    ../Middware/LVGL/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../Middware/LVGL/src/extra/libs/freetype/: lv_freetype.c
    ../Middware/LVGL/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Middware/LVGL/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../Middware/LVGL/src/extra/libs/png/: lodepng.c lv_png.c
    ../Middware/LVGL/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Middware/LVGL/src/extra/libs/rlottie/: lv_rlottie.c
    ../Middware/LVGL/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Middware/LVGL/src/extra/others/gridnav/: lv_gridnav.c
    ../Middware/LVGL/src/extra/others/monkey/: lv_monkey.c
    ../Middware/LVGL/src/extra/others/snapshot/: lv_snapshot.c
    ../Middware/LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ../Middware/LVGL/src/extra/themes/default/: lv_theme_default.c
    ../Middware/LVGL/src/extra/themes/mono/: lv_theme_mono.c
    ../Middware/LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ../Middware/LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middware/LVGL/src/extra/widgets/chart/: lv_chart.c
    ../Middware/LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Middware/LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Middware/LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Middware/LVGL/src/extra/widgets/led/: lv_led.c
    ../Middware/LVGL/src/extra/widgets/list/: lv_list.c
    ../Middware/LVGL/src/extra/widgets/menu/: lv_menu.c
    ../Middware/LVGL/src/extra/widgets/meter/: lv_meter.c
    ../Middware/LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Middware/LVGL/src/extra/widgets/span/: lv_span.c
    ../Middware/LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Middware/LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ../Middware/LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ../Middware/LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ../Middware/LVGL/src/extra/widgets/win/: lv_win.c
    ../Middware/LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Middware/LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Middware/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Middware/LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group App
    ../Middware/App/: my_lvgl_task.c my_lvgl_task.h app_chassis_board.c app_chassis_board.h app_key.c app_key.h app_Navigation.c app_Navigation.h app_remote_control.c app_remote_control.h app_Voice_Recognition.c app_Voice_Recognition.h
  group FreeRTOS
    ../Middware/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middware/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middware/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middware/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group Hardware
    ../Drivers/Hardware/: bsp_encoder.c bsp_encoder.h bsp_exti.c bsp_exti.h bsp_motor.c bsp_motor.h bsp_oled.c bsp_oled.h bsp_oled_font.h bsp_timer.c bsp_timer.h bsp_uart.c bsp_uart.h bsp_QMC5883.c bsp_QMC5883.h bsp_GPS.c bsp_GPS.h bsp_bluetooth.c bsp_bluetooth.h bsp_usb.c bsp_usb.h bsp_JY901S.c bsp_JY901S.h bsp_road_classification.c bsp_road_classification.h bsp_REG.h bsp_wit_c_sdk.c bsp_wit_c_sdk.h bsp_WonderEcho.c bsp_WonderEcho.h bsp_TF_card.c bsp_TF_card.h bsp_tf_image_load.c bsp_tf_image_load.h bsp_fatfs_diskio.c bsp_qspi_flash.c bsp_qspi_flash.h
    ../Drivers/Hardware/NanoEdgeAI/: NanoEdgeAI.h libneai.a
  group Algorithm
    ../Drivers/Algorithm/: pid.c pid.h
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_cdc_if.c usbd_desc.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middware/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middware/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group BSP_LVGL
    ../Middware/LVGL/demos/01_interactive_page/: ui.c ui.h ui_helpers.c ui_helpers.h
    ../Middware/LVGL/demos/01_interactive_page/components/: ui_comp_hook.c
    ../Middware/LVGL/demos/01_interactive_page/fonts/: ui_font_Font1.c ui_font_FontTitle.c ui_font_Font2.c ui_font_Road.c ui_font_CN14.c ui_font_CN64.c ui_font_Font3.c ui_font_Font4.c ui_font_Font5.c
    ../Middware/LVGL/demos/01_interactive_page/screens/: ui_Screenmain.c ui_Screenmain.h ui_Screensettings.c ui_Screensettings.h ui_Login.c ui_Login.h ui_FileManager.c ui_FileManager.h ui_DataDisplay.c ui_DataDisplay.h ui_DataDetail.c ui_DataDetail.h
    ../Middware/LVGL/demos/01_interactive_page/images/: ui_img_1301672413.c ui_img_1943878613.c ui_img_380527393.c ui_img_1565185032.c ui_img_1614311220.c
  group System
    ../Middware/Third_Party/FATFS/: ff.c
software components: CMSIS:CORE 5.6.0
